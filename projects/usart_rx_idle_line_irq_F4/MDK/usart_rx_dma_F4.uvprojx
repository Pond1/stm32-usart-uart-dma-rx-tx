# Keil uVision project usart_rx_dma_F4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usart_rx_dma_F4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32F407xx
  c include: ..\Inc;..\..\..\drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../Src/: main.c stm32f4xx_it.c
  group driver lib
    ../../../drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_dma.c stm32f4xx_ll_usart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c
software components: Device:Startup 2.6.3
